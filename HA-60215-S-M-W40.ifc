Properties of the parts of a building model (IFC2X3)

# File
Time: 2019-09-23T06:32:50
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: HA-60215-M-W40
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: Harrier 4 In-ground luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 3000K and 4000K - Life time L90B10 Ta 25° 200,000,3200,000 - Life time L80B10 Ta 50° 490,000, > 500,000 - Die-cast aluminium housing pre-treated before powder coating ensuring high corrosion resistance - 6 mm thick front ring in stainless steel or aluminium - Single cable entry - Through wiring on request - Stainless steel fasteners in grade 316 - High-efficiency PMMA lens - Durable silicone rubber gasket - Clear, 10 mm thick, toughened glass - Integral control gear - Remote driver is included for HA-60385, HA-60386, HA-60395, HA-60396 - Recessing box in high-density polyethylene is included - Suitable for walk-over with a maximum load of 200 kg; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Harrier, In-ground luminaires; Housing color: White, Black, Silver
General Information - Weight: 2.6 kg; Case length: 20 cm; Case width: 20 cm; Case height: 17.9 cm; Article name: Harrier 4 In-ground luminaires; Uld creation date: 23.09.2019 04:32:50
Photometric Information - Light output ratio: 0.999921; Luminous flux: 2885.23 lm; Lamp names: HA-60215-M-W40
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 29.4 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 29.4 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
Pset_LampTypeCommon - ContributedLuminousFlux: 2885.23 lm; LightEmitterNominalPower: 29.4 W; Spectrum: 380: 0.012934, 385: 0.01155, 390: 0.011614, 395: 0.010494, 400: 0.010484, 405: 0.010279, 410: 0.00968, 415: 0.011352, 420: 0.017493, 425: 0.049381, 430: 0.110001, 435: 0.213323, 440: 0.422394, 445: 0.673726, 450: 0.939462, 455: 0.97829, 460: 0.851938, 465: 0.670014, 470: 0.549521, 475: 0.442322, 480: 0.39367, 485: 0.37832, 490: 0.392506, 495: 0.423255, 500: 0.468951, 505: 0.509823, 510: 0.551923, 515: 0.57673, 520: 0.59894, 525: 0.611155, 530: 0.623829, 535: 0.629598, 540: 0.636475, 545: 0.645361, 550: 0.655589, 555: 0.671682, 560: 0.690295, 565: 0.709359, 570: 0.730587, 575: 0.748998, 580: 0.767832, 585: 0.786295, 590: 0.801043, 595: 0.812518, 600: 0.821303, 605: 0.827334, 610: 0.827494, 615: 0.819016, 616: 0.814072, 617: 0.810179, 618: 0.806287, 619: 0.802012, 620: 0.797737, 625: 0.764787, 630: 0.724964, 635: 0.680899, 640: 0.638133, 645: 0.594845, 650: 0.555125, 655: 0.51894, 660: 0.486181, 665: 0.454614, 670: 0.422297, 675: 0.388355, 680: 0.352992, 685: 0.318193, 690: 0.282697, 695: 0.245701, 700: 0.215906, 705: 0.189853, 710: 0.163229, 715: 0.14476, 720: 0.12737, 725: 0.114158, 730: 0.097674, 735: 0.085444, 740: 0.075708, 745: 0.068751, 750: 0.061453, 755: 0.056451, 760: 0.052251; ColorTemperature: 4032 K; ColorRenderingIndex: 80; ColorAppearance: 4032 K
